# Keil uVision project USART.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\PID;..\HARDWARE\RUNCONTROL;..\HARDWARE\MODBUS;..\HARDWARE\PS;..\HARDWARE\CONTROL;..\HARDWARE\KALMAN;..\HARDWARE\DEALDATA;..\HARDWARE\ENCODER;..\HARDWARE\IIC;..\HARDWARE\GY85;..\FSC_STOS;..\HARDWARE\ERROR;..\HARDWARE\CONTROLTRUN
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c include.h
    ../HARDWARE/LED/: led.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/DEALDATA/: dealdata.c
    ../HARDWARE/ENCODER/: Encoder.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/GY85/: gy85.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/ERROR/: errordetect.c
    ../HARDWARE/KALMAN/: kalman.c
    ../HARDWARE/CONTROLTRUN/: controlturn.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: bsp_usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c
  group FSC_STOS
    ../FSC_STOS/: FSC_STOS.c FSC_STOS.h FSC_STOS.lib main.c
